# Repository vlcampos/JailBarReductorCCE

## KiCad design VideoModCCE/VideoModCCE.kicad_pcb

Parts:
C1: 1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2: 100uF 16V; CP_Radial_D8.0mm_P3.50mm
PIN1, PIN5: GND; TestPoint_Pad_3.0x3.0mm
PIN2: CVBS IN; TestPoint_Pad_3.0x3.0mm
PIN3: +5V; TestPoint_Pad_3.0x3.0mm
PIN4: CVBS OUT; TestPoint_Pad_3.0x3.0mm
Q1: BC558; TO-92_HandSolder
Q2: BC548; TO-92_HandSolder
R1: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 2K2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 75R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 150R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
GND: C1.2, PIN1.1, PIN5.1, Q1.1 (C), R5.2
unnamed: C2.1, R4.2
unnamed: C2.2, PIN4.1
unnamed: PIN2.1, Q1.2 (B)
unnamed: Q1.3 (E), R1.1
unnamed: C1.1, PIN3.1, Q2.1 (C), R2.2
unnamed: Q2.2 (B), R3.2
unnamed: Q2.3 (E), R4.1, R5.1
unnamed: R1.2, R2.1, R3.1

Board: 2 copper layers, 35.0 x 31.2 mm, 14 parts (0 on the bottom side), 9 nets.

## Commit log

2022-05-01 Revision 0
    First iteration of a Jailbar reduction board based on Neto Hacking circuit.
    Primeira versão de placa para redução do Jailbar no vídeo baseado no circuito desenvolvido pelo Neto Hacking.
    https://www.neto-games.com.br/hardware/nes_cce_vg-9000t.php
2022-05-01 Schematic PDF
    Included the schematic in PDF format
2022-05-01 3D Image
    Image of the PCB 3D render
2022-05-01 PCB Schematic Fix
